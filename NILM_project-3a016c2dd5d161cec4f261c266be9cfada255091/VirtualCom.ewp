# IAR project VirtualCom.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2478 NXP LPC2478
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: IAR_LPC_2478_STK
  ICCARM.CCIncludePath2: app\; board\; modules\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: virtual_com.out
  ILINK.IlinkIcfFile: config\LPC2478_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: IAR_LPC_2478_STK; SDRAM_DEBUG
  ILINK.IlinkIcfFile: config\LPC2478_SDRAM.icf
  group (top)
    app/: main.c main.h
    ./: readme.txt
  group Modules
    app/: algo.c algo.h button_back.c button_back.h button_devices.c button_devices.h button_info.c button_info.h button_learn.c button_learn.h button_monitor.c button_monitor.h button_server.c button_server.h button_settings.c button_settings.h cursor_arrow.c cursor_arrow.h drv_touch_scr.c drv_touch_scr.h gui.c gui.h lamp_off.c lamp_off.h lamp_on.c lamp_on.h
    board/: sys.c
  group Modules/Fonts
    app/: Terminal_18_24x12.c Terminal_6_8x6.c Terminal_9_12x6.c
  group Modules/GLCD
    modules/: drv_glcd.c
  group Modules/Pictures
    app/: iar_logo.c
  group Modules/SDRAM
    modules/: sdram_64M_32bit_drv.c
  group Modules/UARTs
    app/: uart.c
  group USB/Class
    app/: cd_class.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
